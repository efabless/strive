# Repository efabless/strive

File README.md:

# striVe SoC Development Board Design & Documentation

------>>>> WORK IN PROGRESS <<<<-------

## KiCad design pcb/striVe_pcb.kicad_pcb

Parts:
C1, C15: 0.01uf - CC0805JRX7R9BB103; C_0805_2012Metric
C2, C3, C4, C5, C6, C7, C8, C13, C14, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30: 0.1uf - CC0805KRX7R9BB104; C_0805_2012Metric
C9, C11, C35, C36: 10uf - CC0805KKX5R8BB106; C_0805_2012Metric
C10, C12: 22uf - CC0805MKX5R5BB226; C_0805_2012Metric
C31, C32, C33, C34: 100uf - GRM31CR60J107ME39L; C_1206_3216Metric
C37, C38: 1uf; C_0805_2012Metric
C39: 0.1uf- CC0805KRX7R9BB104; C_0805_2012Metric
D0, D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17: LED - 17-215SURC/S530-A2/TR8; LED_1206_3216Metric
F1, F2, F3, F4: Fuse - KT8-1000SMD1206; Fuse_1206_3216Metric
IC1: 93C56; SOT-23-6
IC2: TMUX1574DYYR; QFN40P180X260X55-16N; Mouser Part Number 595-TMUX1574RSVR
J1, J2: USB_B_Micro - 10118193-0001LF; FCI_10118193-0001LF
J3, J6, J7: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
J4, J5: Conn_01x18_Female; PinHeader_1x18_P2.54mm_Vertical
J8: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
R0, R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15: 82 - 0805W8F820JT5E; R_0805_2012Metric
R16, R17, R19, R20, R22, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34: 10k - RC0805FR-0710KL; R_0805_2012Metric
R18: 2K - CR0805J80202G; R_0805_2012Metric
R21: 12K 1% - 0805W8F1202T5E; R_0805_2012Metric
R23, R24: 150 - 0805W8J0151T5E; R_0805_2012Metric
R35: 1k; R_0805_2012Metric
R_sense_1V8, R_sense_3V3: 0.3; R_0805_2012Metric
SW0, SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16: SW_Push - SKQGADE010; SW4-SMD-5.2X5.2X1.5MM
SW17: SMD-TOGGLE-SWITCH - MS-22D18 G2 ROHS; SW6-2.54-9.0X3.5X3.2+2.0MM
T1: Logo; logo
U1: FT232H; LQFP-48_7x7mm_P0.5mm
U2: AZ1117CH-1.8TRG1; SOT-223
U3: MCP1826ST-3302E/DB; SOT-223
U4: W25Q32FVSS; SOIC127P790X216-8N
U5: INA2181-Q1; VSSOP-10_3x3mm_P0.5mm
U6: DS1086; MSOP-8_3x3mm_P0.65mm
U7: MCP2221A; SOIC-14_3.9x8.7mm_P1.27mm
U8: striVe2_pkg_symbol; QFN-56-1EP_8x8mm_P0.5mm_EP5.6x5.6mm
U9: MCP1319; SOT-23-5
X1: DSC6001_10MHZ; DSC6001JE1A-010.0000
Y1: CSTNE12M0GH5L000R0

Connections:
+1V8: C10.2, C35.2, C37.2, J4.17, J5.17, J7.1, J7.2, R_sense_1V8.2, U2.2 (VO), U5.7 (IN+2)
+3V3: C4.2, C5.2, C6.2, C7.2, C8.2, C12.2, C13.1, C14.2, C15.2, C16.2, C25.2, C26.1, C36.2, C38.2, IC1.6 (VCC), IC2.16 (VDD), J3.1, J4.18, J5.18, J6.1, J6.2, J8.3, R16.2, R17.2, R19.1, R20.2, R22.1, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R32.1, R33.1, R34.2, R35.2, R_sense_3V3.2, U1.3 (VPHY), U1.8 (VPLL), U1.12 (VCCIO), U1.24 (VCCIO), U1.39 (VCCD), U1.40 (VREGIN), U1.46 (VCCIO), U3.3 (VO), U4.8 (VCC), U5.3 (IN+1), U5.10 (VS), U6.3 (VCC), U7.1 (VDD), U9.5 (VDD), X1.4 (V+)
+5V: C9.2, C11.2, C31.2, C32.2, C33.2, C34.2, SW17.COM1, SW17.COM2, U2.3 (VI), U3.1 (VI)
CSA1V8: U5.9 (OUt2), U7.7 (GP2)
CSA3V3: U5.1 (OUT1), U7.3 (GP1)
EECLK: IC1.4 (CLK), R16.1, U1.44 (EECLK)
EECS: IC1.5 (CS), R17.1, U1.45 (EECS)
EEDATA: IC1.1 (DO), R18.2, R19.2, U1.43 (EEDATA)
FTDI_5V: J1.1 (VBUS), SW17.CH1B, SW17.CH2B
FTDI_D+: F3.1, J1.3 (D+), U1.7 (DP)
FTDI_D-: F1.1, J1.2 (D-), U1.6 (DM)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.2, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.2, C22.2, C23.2, C24.2, C25.1, C26.2, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.2, F1.2, F2.2, F3.2, F4.2, IC1.2 (GND), IC2.8 (GND), IC2.15 (~EN), J1.5 (GND), J2.5 (GND), J5.15, J5.16, J8.1, R21.1, R31.2, SW0.2, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, SW13.2, SW14.2, SW15.2, SW16.2, U1.4 (AGND), U1.9 (AGND), U1.10 (GND), U1.11 (GND), U1.22 (GND), U1.23 (GND), U1.35 (GND), U1.36 (GND), U1.41 (AGND), U1.42 (TEST)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
GPIO0: D0.1 (K), J4.1, SW0.1, U8.39 (gpio[0])
GPIO1: D1.1 (K), J4.2, SW1.1, U8.38 (gpio[1])
GPIO2: D2.1 (K), J4.3, SW2.1, U8.37 (gpio[2])
GPIO3: D3.1 (K), J4.4, SW3.1, U8.36 (gpio[3])
GPIO4: D4.1 (K), J4.5, SW4.1, U8.35 (gpio[4])
GPIO5: D5.1 (K), J4.6, SW5.1, U8.50 (gpio[5])
GPIO6: D6.1 (K), J4.7, SW6.1, U8.51 (gpio[6])
GPIO7: D7.1 (K), J4.8, SW7.1, U8.52 (gpio[7])
GPIO8: D8.1 (K), J4.9, SW8.1, U8.53 (gpio[8])
GPIO9: D9.1 (K), J4.10, SW9.1, U8.29 (gpio[9])
GPIO10: D10.1 (K), J4.11, SW10.1, U8.28 (gpio[10])
GPIO11: D11.1 (K), J4.12, SW11.1, U8.40 (gpio[11])
GPIO12: D12.1 (K), J4.13, SW12.1, U8.46 (gpio[12])
GPIO13: D13.1 (K), J4.14, SW13.1, U8.47 (gpio[13])
GPIO14: D14.1 (K), J4.15, SW14.1, U8.48 (gpio[14])
GPIO15: D15.1 (K), J4.16, SW15.1, U8.49 (gpio[15])
I2C_SCL: R32.2, U6.8 (SCL), U7.10 (SCl)
I2C_SDA: R33.2, U6.7 (SDA), U7.9 (SDA)
LED_CA: J8.2, R0.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1
MCP2221_GP0: U7.2 (GP0), X1.1 (EN)
MCP2221_GP3: R31.1, U6.2 (SPRD), U6.5 (OE), U6.6 (~PDN), U7.8 (GP3)
MCP_5V: J2.1 (VBUS), SW17.CH1A, SW17.CH2A
MCP_D+: F4.1, J2.3 (D+), U7.13 (D+)
MCP_D-: F2.1, J2.2 (D-), U7.12 (D-)
MEM_CS: IC2.4 (D1), R25.1, U4.1 (~CS~)
MEM_SCK: IC2.12 (D4), R29.1, U4.6 (SCK)
MEM_SI: IC2.9 (D3), R28.1, U4.5 (SI(D0))
MEM_SO: IC2.7 (D2), R26.1, U4.2 (SO(D1))
unnamed: C1.2, R20.1, U1.34 (~RESET)
unnamed: C2.2, U1.38 (VCCCORE)
unnamed: C3.2, U1.37 (VCCA)
unnamed: C27.2, U7.11 (VUSB)
unnamed: D0.2 (A), R0.2
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2
unnamed: D5.2 (A), R5.2
unnamed: D6.2 (A), R6.2
unnamed: D7.2 (A), R7.2
unnamed: D8.2 (A), R8.2
unnamed: D9.2 (A), R9.2
unnamed: D10.2 (A), R10.2
unnamed: D11.2 (A), R11.2
unnamed: D12.2 (A), R12.2
unnamed: D13.2 (A), R13.2
unnamed: D14.2 (A), R14.2
unnamed: D15.2 (A), R15.2
unnamed: D16.1 (K), U1.27 (ACBUS3)
unnamed: D16.2 (A), R23.1
unnamed: D17.1 (K), U1.26 (ACBUS2)
unnamed: D17.2 (A), R24.1
unnamed: IC1.3 (DI), R18.1
unnamed: R21.2, U1.5 (REF)
unnamed: R35.1, U7.4 (~RST)
unnamed: U1.1 (XCSI), Y1.1
unnamed: U1.2 (XCSO), Y1.3
RST: U9.3 (RST)
SPI_CSB: J5.12, U1.16 (ADBUS3), U8.11 (CSB)
SPI_SCK: J5.9, U1.13 (ADBUS0), U8.10 (SCK)
SPI_SDI: J5.11, U1.14 (ADBUS1), U8.43 (SDI)
SPI_SDO: J5.10, R22.2, U1.15 (ADBUS2), U8.44 (SDO)
STRIVE_1V8: C17.2, C23.1, C30.2, C39.1, R_sense_1V8.1, U5.8 (IN-2), U8.13 (VDD1V8), U8.18 (VDD1V8), U8.32 (VDD1V8), U8.55 (VDD1V8)
STRIVE_3V3: C18.2, C19.2, C20.2, C21.1, C22.1, C24.1, C28.2, C29.2, R_sense_3V3.1, U5.2 (IN-1), U8.1 (VDD3V3), U8.14 (VDD3V3), U8.15 (VDD3V3), U8.16 (VDD3V3), U8.17 (VDD3V3), U8.30 (VDD3V3), U8.31 (VDD3V3), U8.56 (VDD3V3)
STRIVE_CSB: IC2.2 (S1A), J5.8, U8.42 (flash_csb)
STRIVE_D0: IC2.11 (S3A), J5.6, U8.7 (flash_io0)
STRIVE_D1: IC2.5 (S2A), J5.5, U8.6 (flash_io1)
STRIVE_D2: J5.4, R27.1, U4.3 (~WP~(D2)), U8.5 (flash_io2)
STRIVE_D3: J5.3, R30.1, U4.7 (~HOLD~(D3)), U8.4 (flash_io3)
STRIVE_RX: J5.1, U7.6 (UTx), U8.2 (ser_rx)
STRIVE_SCK: IC2.14 (S4A), J5.7, U8.8 (flash_clk)
STRIVE_TX: J5.2, U7.5 (URx), U8.3 (ser_tx)
TMUX_SEL: IC2.1 (SEL), J3.2, U1.21 (ACBUS0)
USB_CS: IC2.3 (S1B), U1.20 (ADBUS7)
USB_SCK: IC2.13 (S4B), U1.17 (ADBUS4)
USB_SI: IC2.6 (S2B), U1.19 (ADBUS6)
USB_SO: IC2.10 (S3B), U1.18 (ADBUS5)
xclk: U6.1 (OUT), U8.9 (xclk), X1.3 (OUT)
xi: J5.14, U8.27 (xi)
xo: J5.13, U8.26 (xo)
~MR: R34.1, SW16.1, U9.4 (~MR)
~RST: U8.12 (RSTB), U9.1 (~RST)

Board: 2 copper layers, 60.0 x 100.0 mm, 139 parts (0 on the bottom side), 93 nets.

## Commit log

2021-05-08 Initial commit to publish striVe SoC development board and sw.

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
